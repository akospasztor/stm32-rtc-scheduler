# IAR project stm32-rtc-scheduler.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../../include; ../../lib/FreeRTOS/include; ../../lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../drivers/CMSIS/Include; ../../drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../drivers/STM32L4xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../include
  OBJCOPY.OOCOutputFile: stm32-rtc-scheduler.bin
  ILINK.IlinkOutputFile: stm32-rtc-scheduler.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Application/Include
    ../../include/: core_stop.h error_handler.h freertos_tasks_c_additions.h FreeRTOSConfig.h hardware.h main.h rtc.h scheduler.h stm32l4xx_hal_conf.h
  group Application/Source
    ../../source/: core_stop.c error_handler.c hardware.c main.c rtc.c scheduler.c stm32l4xx_hal_timebase.c stm32l4xx_it.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Lib/FreeRTOS
    ../../lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Lib/FreeRTOS/portable
    ../../lib/FreeRTOS/portable/MemMang/: heap_1.c
    ../../lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
