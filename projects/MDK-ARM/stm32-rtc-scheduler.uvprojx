# Keil uVision project stm32-rtc-scheduler.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32-rtc-scheduler +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,USE_FULL_ASSERT
  c include: ../../include;../../lib/FreeRTOS/include;../../lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../drivers/CMSIS/Include;../../drivers/CMSIS/Device/ST/STM32L4xx/Include;../../drivers/STM32L4xx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/Include
    ../../include/: core_stop.h error_handler.h freertos_tasks_c_additions.h FreeRTOSConfig.h hardware.h main.h rtc.h scheduler.h stm32l4xx_hal_conf.h
  group Application/Source
    ../../source/: core_stop.c error_handler.c hardware.c main.c rtc.c scheduler.c stm32l4xx_hal_timebase.c stm32l4xx_it.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Lib/FreeRTOS
    ../../lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Lib/FreeRTOS/portable
    ../../lib/FreeRTOS/portable/MemMang/: heap_1.c
    ../../lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
